# Keil uVision project Project.uvprojx, settings and files
target PREDMNT1_STWIN (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L4R9ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IROM(0x08000000-0x81FFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM(0x0-0xFFFFFFFFFFFFFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM3(0x0-0xFFFFFFFFFFFFFFFF) IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IRAM(0x0-0xFFFFFFFFFFFFFFFF) IRAM2(0x0-0xFFFFFFFFFFFFFFFF) IRAM3(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L4R9ZI-STWIN_PredictiveMaintenance
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,BLUENRG1_NWK_COPROC,SPI_INTERFACE,ARM_MATH_CM4
  c include: ..\Inc;..\Patch;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\..\..\Drivers\BSP\STWIN;..\..\..\..\..\Middlewares\ST\BlueNRG-2\includes;..\..\..\..\..\Middlewares\ST\BlueNRG-2\utils;..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\Middlewares\ST\STM32_MotionSP_Library\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\Middlewares\ST\STM32_BLE_Manager\Inc;..\..\..\..\..\Middlewares\Third_Party\parson;..\..\..\..\..\Middlewares\ST\BlueNRG-2\hci\hci_tl_patterns\Basic
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT5: ROM 0x4c778a14 size 0xe000000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group MDK-ARM
    ./: startup_stm32l4r9xx.s
  group User/Patch
    ../Patch/: ism330dhcx_Patch.c STWIN_motion_sensors_ex_Patch.c
  group User
    ../Src/: BLE_Implementation.c hci_tl_interface.c main.c MotionSP_Manager.c OTA.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
  group Drivers/BSP/STWIN
    ../../../../../Drivers/BSP/STWIN/: STWIN.c STWIN_audio.c STWIN_bc.c STWIN_bus.c STWIN_env_sensors.c STWIN_motion_sensors.c STWIN_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/BlueNRG-2
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group json
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AudioLevel.c BLE_Battery.c BLE_Environmental.c BLE_FFT_AlarmAccPeakStatus.c BLE_FFT_AlarmSpeedStatus.c BLE_FFT_AlarmSubrangeStatus.c BLE_FFT_Amplitude.c BLE_Inertial.c BLE_Manager.c BLE_TimeDomain.c
  group Middlewares/STM32_MotionSP
    ../../../../../Middlewares/ST/STM32_MotionSP_Library/Src/: MotionSP.c
  group Middlewares/STM32_USBD_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
